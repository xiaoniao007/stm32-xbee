# Keil uVision project CSA.uvproj, settings and files
target READBMP (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: readbmp +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\User;..\..\User\Key;..\..\User\ff9;..\..\User\Led;..\..\User\ov7725;..\..\User\usart;..\..\User\sdcard;..\..\User\delay;..\..\User\spi;..\..\User\zigbee;..\..\User\save;..\..\User\lcd;..\..\User\rtc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group COMSIS
    ../../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c stm32f10x_conf.h time2.c
    ../../User/usart/: bsp_usart1.c
    ../../User/sdcard/: bsp_sdfs_app.c bsp_sdio_sdcard.c
    ../../User/lcd/: bsp_ili9341_lcd.c
    ../../User/Key/: bsp_exti.c
    ../../User/ov7725/: bsp_ov7725.c bsp_sccb.c
    ../../User/Led/: bsp_led.c
    ../../User/delay/: delay.c
    ../../User/spi/: bsp_spi_flash.c
    ../../User/zigbee/: zig.c
    ../../User/save/: save.c
    ../../User/rtc/: bsp_rtc.c bsp_calendar.c bsp_date.c
  group ff9
    ../../User/ff9/: ff.c diskio.c
    ../../User/ff9/option/: cc936.c
